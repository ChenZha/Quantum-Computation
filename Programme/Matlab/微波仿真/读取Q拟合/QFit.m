QFit.m:
```
%利用拟合的方式计算f0，Qi，Qc
% function Q = QFit(path )
% 先利用Qcal计算，将计算结果作为Q0，然后进行拟合 
% 两种方式，一种nlinfit，一种fmincon 
%% 读取数据

 
% if (nargin<1)
        path = 'RO_1.s2p';
% end

ckt=read(rfdata.data, path);
f = reshape(ckt.Freq,1,length(ckt.Freq));
S = ckt.S_Parameters;
S_21 = reshape(S(2,1,:),1,length(S(2,1,:)));
% figure();plot(f,20*log10(abs(S_21)));xlabel('Freq/GHz');ylabel('Mag(dB)');
% figure();plot(f,angle(S_21));xlabel('Freq/GHz');ylabel('Ang(dB)');
S_21 = 1./S_21-1;%求S21^(-1)-1
%%
% figure();plot(f,20*log10(abs(S_21)));xlabel('Freq/GHz');ylabel('Mag(dB)');
figure();plot(S_21,'b');xlabel('Re(S_{21}^{-1})');ylabel('Im(S_{21}^{-1})');hold on;

% nlinfit
Q0 = [10e+05,1e+04,0.01,6.662e+09];
modulefun = @S21;
Q = nlinfit(f,S_21,modulefun,Q0);

% fmincon
% modulefun = @(b)deviation(b,S_21,f);
% A = [];b = [];Aeq = [];beq = [];
% lb = [10000,1000,0,6.7e+9];
% ub = [2000000,200000,pi/2,6.8e+9];
% 
% Q0 = [9e+05,1e+04,0.01,6.78e+09];
% 
% Q,val = fminsearch(modulefun,Q0);
% disp(val)

s = S21(Q,f(1:2:end));
plot(s,'r*');
disp(['Qi=',num2str(Q(1))]);
disp(['Qc=',num2str(Q(2))]);
disp(['phi=',num2str(Q(3))]);
disp(['f0=',num2str(Q(4))]);
% end

function p = S21(b,f)
Qi =b(1);Qc = b(2);phi = b(3);f0 = b(4);
p = Qi/Qc*exp(1i*phi)./(1+2*1i*Qi*(f-f0)/f0);
end

function e = deviation(b,S_21,f)
error = S_21-S21(b,f);
e = sum(abs(error));
end
```
RO_1.s2p:
! Sonnet Data File
! From: em Version : 14.52
! From Project: RO_1
! Data is De-embedded
! Data File Written: 01/08/2019 21:02:42
!< HDATE 01/08/2019 00:45:15
!< MDATE 01/08/2019 20:28:25
# GHZ S MA R 50.00000
! Worked out from all points (narrow notch):
!   961 points, 6 GHz to 6.8 GHz, reference 50 ohm
!   highest |S21| = 0.00 dB at 6.6875 GHz (marker M1); lowest = -38.5 dB at 6.6612 GHz (marker M2)
!   notch at M2: 38.4 dB deep, 55.7 kHz wide at half that depth
!   lowest |S11| = -60.4 dB at 6.6875 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.0276 ohm
!   |S11| at or under -10 dB: start of sweep to 6.6605 GHz; 6.662 GHz to end of sweep
!   |S22| runs from -60.5 to -0.1 dB; largest |S21 - S12| = 0
!   S11 on the Smith chart (normalised r, x): 6 GHz: 1.00, +0.02; 6.6609 GHz: 1.21, +1.59; 6.6612 GHz: 3, +10; 6.6613 GHz: 0.68, -4.20; 6.6616 GHz: 0.87, -1.27; 6.8 GHz: 1.00, +0.02
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6  0.009388 79.2  1 -12.2  1 -12.2  0.009388 76.4
!< P1 F=6.0 Eeff=(5.67080918 -5.1691e-6) Z0=(51.6560295 2.35492e-5) R=0.01071313 C=0.0022568
!< P2 F=6.0 Eeff=(5.67080918 -5.1691e-6) Z0=(51.6560295 2.35492e-5) R=0.01071313 C=0.0022568
6.4  0.01057 78.7  0.9999 -13.0  0.9999 -13.0  0.01057 75.3
6.64  0.02184 79.9  0.9998 -14.1  0.9998 -14.1  0.02184 71.8
6.66089  0.5894 46.7  0.8028 -49.0  0.8028 -49.0  0.5894 34.3
6.66116  0.9442 10.6  0.2952 -83.5  0.2952 -83.5  0.9442 -2.0
6.661239  0.9881 -6.5  0.0119 -16.9  0.0119 -16.9  0.9881 -19.2
6.66133  0.9308 -26.1  0.3355 55.6  0.3355 55.6  0.9308 -38.8
6.6616  0.5661 -61.5  0.8195 21.6  0.8195 21.6  0.5661 -74.3
6.6674  0.03105 -93.2  0.9995 -11.1  0.9995 -11.1  0.03105 -109.0
6.6875  0.0009506 16.9  1 -13.0  1 -13.0  0.0009478 137.1
6.8  0.008393 76.7  1 -13.6  1 -13.6  0.008393 76.1
